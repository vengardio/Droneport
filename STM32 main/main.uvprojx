# Keil uVision project main.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  c misc: -w
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: adc.c dht22.c gpio.c led_blink.c main.c pwm.c rcc.c usart1.c adc.h dht22.h gpio.h led_blink.h main.h pwm.h rcc.h usart1.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.3.1
